LED_FILE_firefly-rk3288 = "/sys/class/leds/blue/brightness"
LED_FILE_aio-3288c = "/sys/class/leds/blue/brightness"
