# Flash to internal eMMC - kernel enumerates this, when SD card is in, as mmcblk1
INTERNAL_DEVICE_KERNEL_firefly-rk3288 = "mmcblk2"
INTERNAL_DEVICE_KERNEL_aio-rk3288c = "mmcblk2"
